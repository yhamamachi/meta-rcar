RDEPENDS_${PN} += " \
   nativesdk-cmake \
   nativesdk-protobuf \
"
