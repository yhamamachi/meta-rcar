
RRECOMMENDS_${PN} += " \
	gcc-sanitizers \
    "
