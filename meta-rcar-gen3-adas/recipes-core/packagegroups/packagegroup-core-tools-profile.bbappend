
RRECOMMENDS_${PN} += " \
    cpuburn-arm \
    rsync \
    htop \
    sysstat \
    sysstat-contrib \
"
