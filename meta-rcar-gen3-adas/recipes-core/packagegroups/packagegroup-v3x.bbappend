CPURTT_PKGS_v3hsk = " \
    kernel-module-cpurttdrv \
    kernel-module-cpurttdrv2 \
"
CPURTT_PKGS_v3msk = " \
    kernel-module-cpurttdrv \
    kernel-module-cpurttdrv2 \
"

