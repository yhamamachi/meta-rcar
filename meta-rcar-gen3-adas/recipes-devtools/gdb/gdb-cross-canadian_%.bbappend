# The patch is included in poky.
# The patch is needed for mingw toolchain build.

SRC_URI += "file://force-readline-static.patch"
