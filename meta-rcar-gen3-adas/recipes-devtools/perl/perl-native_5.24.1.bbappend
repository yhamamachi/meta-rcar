FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

SRC_URI += "file://perl-5.26.1-guard_old_libcrypt_fix.patch"
