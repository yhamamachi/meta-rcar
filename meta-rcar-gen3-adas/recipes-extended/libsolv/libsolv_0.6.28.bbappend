FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"


SRC_URI += " \
    file://0001-don-t-pick-up-bundled-db-from-host-rpm.patch \
"

