module_conf_cmemdrv = "options cmemdrv bsize=0x10000000"

