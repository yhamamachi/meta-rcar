FILES_${PN} += " \
            ${SDKPATHNATIVE}/usr/share/cmake/OEToolchainConfig.cmake.d \
"
