QT_MODULE_BRANCH = "2.1"
QT_GIT_PROJECT = "qt3dstudio"
PV = "2.1+git${SRCPV}"

SRCREV = "95942f6b187c5272074c191424a18e33f8516967"