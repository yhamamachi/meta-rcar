require glm.inc

LIC_FILES_CHKSUM = "file://copying.txt;md5=4431606d144252143c9c3df384a74cad"

SRC_URI_append = " \
    file://0001-Fix-cmake-pathes.patch \
"

SRC_URI[md5sum] = "70eac538d5681132dd363f814c81ce22"
SRC_URI[sha256sum] = "80cf9958f06e5504f8df45ea14fde87411270102930be31c0a16c0da430fc920"

